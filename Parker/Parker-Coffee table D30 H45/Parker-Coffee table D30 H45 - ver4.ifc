Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Parker-Coffee table D30 H45 - ver4.ifc
Time: 2024-11-21T09:07:16
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (2)
Name
 | Parker-Coffee table D30 H45_0 - ObjectType: SketchupGroup
 | Parker-Coffee table D30 H45_1 - ObjectType: SketchupGroup
